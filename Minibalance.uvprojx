# Keil uVision project Minibalance.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\TIMER;..\HARDWARE\IIC;..\BALANCE\DMP;..\BALANCE\filter;..\BALANCE\MPU6050;..\FALIB\inc;..\USER;..\CORE;..\SYSTEM\key;..\SYSTEM\ws2812b;..\SYSTEM\DMA1;..\SYSTEM\TIM2;..\SYSTEM\TIM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: Minibalance.c stm32f10x_it.c
  group BALANCE
    ../BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BALANCE/filter/: filter.c
    ../BALANCE/MPU6050/: MPU6050.c
  group HARDWARE
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/TIMER/: timer.c
  group Source Group 1
    ./: startup_stm32f10x_md.s
    ../CORE/: core_cm3.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/key/: key.c
    ../SYSTEM/DMA1/: DMA1.c
    ../SYSTEM/ws2812b/: ws2812b.c
    ../SYSTEM/TIM2/: TIM2.c TIM2.h
    ../SYSTEM/TIM3/: TIM3.c TIM3.h
  group FALIB
    ../FALIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.0.0
